ORG 0000h
LJMP MAIN

ORG 0100h
MAIN:

MOV r1, #81h ;MSB
MOV r0, #82h ;LSB
MOV @r0, #0ffh
MOV @r1, #0ffh
MOV r2,#0h
MOV r3,#00fh

LED:
MOV P1,#0f0h

LOOP1: 
LCALL DELAY
DJNZ r3,LOOP1
MOV r3,#00fh

MOV P1,#00h

LOOP2:
LCALL DELAY
DJNZ r3,LOOP2
MOV r3,#00fh

SJMP LED

DELAY:
MOV B,@r1
;INC B

L1: DJNZ B,L2
SJMP L3

L2: DJNZ r2,L2
SJMP L1

L3:MOV B,@r0  ;LSB

L4: DJNZ B,L4 ;LSB
RET

END